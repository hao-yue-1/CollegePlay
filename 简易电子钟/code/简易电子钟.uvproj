# Keil uVision project 简易电子钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 简易电子钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd12864.c display.c time.c menu.c eeprom.c iic.c

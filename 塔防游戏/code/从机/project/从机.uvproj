# Keil uVision project 从机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 从机 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c usart.c checkpoint.c game.c lcd12864.c menu.c select.c score.c eeprom.c iic.c arrow.c information.c
